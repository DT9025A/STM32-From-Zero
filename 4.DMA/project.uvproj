# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Driver;.\Lib\inc;.\Startup;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./Startup/: startup_stm32f10x_md.s
  group LIB
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_dma.c
  group USER
    ./User/: main.c
  group DRIVERS
    ./Driver/: sys.c delay.c
